# Keil uVision project Project.uvprojx, settings and files
target GD32F450 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F450VI GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x070000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: IR101RC09-G-WG +hex
  AfterMake: fromelf.exe  --bin -o  ./output/@L.bin  ./output/@L.axf
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F450
  c include: ..\inc;..\..\..\Library\Firmware\CMSIS;..\..\..\Library\Firmware\GD32F4xx_standard_peripheral\Include;..\..\Utilities\Third_Party\uCOS_III\uC-CPU;..\..\Utilities\Third_Party\uCOS_III\uCOS-III;..\..\Utilities\Third_Party\uCOS_III\UCOS_BSP;..\..\Utilities\Third_Party\uCOS_III\uCOS_CONFIG;..\..\Utilities\Third_Party\uCOS_III\uCOS-III\Source;..\..\Utilities\Third_Party\uCOS_III\uC-LIB\Ports\ARM-Cortex-M4\RealView;..\..\Utilities\Third_Party\uCOS_III\uC-LIB;..\..\Utilities\Third_Party\uCOS_III\uC-CPU\ARM-Cortex-M4\RealView;..\..\Utilities\Third_Party\uCOS_III\uCOS-III\Ports\ARM-Cortex-M4\Generic\RealView;..\..\Utilities;..\..\Utilities\Third_Party\lwip-1.4.1\src\include;..\..\Utilities\Third_Party\lwip-1.4.1\src\include\ipv4;..\..\Utilities\Third_Party\lwip-1.4.1\src\include\netif;..\..\Utilities\Third_Party\lwip-1.4.1\src\include\lwip;..\..\Utilities\Third_Party\lwip-1.4.1\port\GD32F4xx;..\..\Utilities\Third_Party\lwip-1.4.1\port\GD32F4xx\Basic;..\src;..\src\common;..\src\log;..\src\wdt;..\src\ex_flash\spinand;..\src\network\udp;..\src\sys;..\src\interface;..\src\task\task_pc_comm;..\src\api\api_sys_param;..\src\api\api_gpio;..\src\protocol\port_sf_app;..\..\Utilities\Third_Party\lwip-1.4.1\src\include\ipv4\lwip;..\src\protocol\prot_cmd_pool;..\src\protocol\port_sf;..\src\task\task_can_comm;..\src\task\task_slave_comm;..\src\protocol\prot_can_simple;..\src\protocol\prot_sf_can;..\src\protocol\prot_sf_slave;..\src\api\api_can_dm;..\src\log;..\src\api\api_record_manage;..\src\task\task_record;..\src\task\task_can_upgrade;..\src\task\task_can_test;..\src\physical\can;..\src\physical\enet;..\src\physical\enet\udpgroup;..\src\physical\enet\tcpserver;..\src\physical\Flash_if;..\src\physical\gpio;..\src\physical\rtc;..\src\physical\spi;..\src\physical\spinand;..\src\physical\uart;..\src\physical\enet\enet;..\src\physical\enet\netconf;..\src\driver\enet\tcpserver;..\src\driver\enet\udpgroup;..\src\driver\Flash_if;..\src\driver\gpio;..\src\driver\can;..\src\driver\spinand;..\src\driver\uart;..\src\task\task_network\httpserver;..\src\task\task_network\httpserver\config;..\src\task\task_network\httpserver\login;..\src\task\task_network\httpserver\password;..\src\task\task_network\httpserver\upgrade;..\src\task\task_network\telnet;..\src\physical\enet\tcpclient;..\src\driver\enet\tcpclient;..\src\api\api_at;..\src\api\api_lte;..\src\api\api_upgrade;..\src\console;..\src\task\task_app_comm;..\src\task\task_module;..\src\task\task_tooling_test;..\src\protocol;..\src\protocol\prot_rfid_5a55;..\src\protocol\prot_rfid_5a55_app;..\src\protocol\prot_rfid_tag;..\src\protocol\prot_rifd_5a55_cmd_pool;..\src\driver\wiegand;..\src\task\task_network\httpserver\config_English;..\src\task\task_network\httpserver\login_English;..\src\task\task_network\httpserver\password_English;..\src\task\task_network\httpserver\upgrade_English;..\src\physical\Wiegand;..\src\driver\enet\udp;..\src\physical\enet\udp
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x70000
  memory RVCT9: RAM 0x20000000 size 0x70000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\DTU-SF.sct
  link misc: --keep *.o(inf.item.*)
--keep *.o(init.item.*)
--keep *.o(period.item.*)
--keep *.o(task.item.*)
  group start
    ../src/: main.c
  group task
    ../src/task/task_module/: task_module_comm.c
  group telnet
    ../src/task/task_network/telnet/: telnet.c
  group console
    ../src/console/: cli_cmd.c console_uart.c
  group common
    ../src/common/: common.c
  group api
    ../src/api/api_sys_param/: api_sys_param.c
    ../src/api/api_gpio/: api_gpio.c
    ../src/api/api_at/: at_utils.c
    ../src/api/api_upgrade/: api_upgrade.c
  group sys
    ../src/sys/: sys_mutex.c sys_base.c sys_sem.c sys_monitor.c sys_timer.c sys_ringbuff.c sys_module.c sys_critical.c
  group interface
    ../src/interface/: interface.c
  group driver
    ../src/driver/enet/tcpserver/: llif_tcpserver.c tcpserverbuff.c
    ../src/driver/enet/udpgroup/: llif_udpgroup.c udpgroupbuff.c
    ../src/driver/can/: llif_can.c canbuff.c
    ../src/driver/Flash_if/: llif_inter_flash.c
    ../src/driver/gpio/: llif_gpio.c
    ../src/driver/uart/: llif_uart.c
    ../src/driver/enet/tcpclient/: llif_tcpclient.c tcpclientbuff.c
    ../src/driver/enet/udp/: llif_udp.c udpbuff.c
  group physical
    ../src/physical/enet/netconf/: netconf.c
    ../src/physical/enet/tcpserver/: tcpserver.c
    ../src/physical/enet/udpgroup/: udpgroup.c
    ../src/: gd32f4xx_it.c
    ../src/physical/enet/enet/: bsp_enet.c
    ../src/physical/Flash_if/: bsp_flash_if.c
    ../src/physical/spinand/: gd5f1g.c
    ../src/physical/can/: bsp_can.c
    ../src/physical/spi/: bsp_spi.c
    ../src/physical/uart/: bsp_uart.c
    ../src/physical/gpio/: bsp_gpio.c
    ../src/physical/rtc/: bsp_rtc.c
    ../src/physical/enet/tcpclient/: tcpclient.c
    ../src/physical/Wiegand/: wiegand.c
    ../src/physical/enet/udp/: udp_ip_search.c
  group log
    ../src/log/: dbg_log.c
  group lwip
    ../../Utilities/Third_Party/lwip-1.4.1/port/GD32F4xx/Basic/: ethernetif.c
    ../../Utilities/Third_Party/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../Utilities/Third_Party/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../../Utilities/Third_Party/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../Utilities/Third_Party/lwip-1.4.1/src/netif/: etharp.c
  group CMSIS
    ../src/: system_gd32f4xx.c
    ../../../Library/Firmware/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450.s
  group peri_lib
    ../../../Library/Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group uC/OSIII_Core
    ../../Utilities/Third_Party/uCOS_III/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group uC/OSIII_Port
    ../../Utilities/Third_Party/uCOS_III/uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group uC/OSIII_Lib
    ../../Utilities/Third_Party/uCOS_III/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../../Utilities/Third_Party/uCOS_III/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group uC/OSIII_BSP
    ../../Utilities/Third_Party/uCOS_III/uCOS_BSP/: bsp.c
  group uC/OSIII_CPU
    ../../Utilities/Third_Party/uCOS_III/uC-CPU/: cpu_core.c
    ../../Utilities/Third_Party/uCOS_III/uC-CPU/ARM-Cortex-M4/RealView/: cpu_a.asm cpu_c.c
  group uC/OSIII_Config
    ../../Utilities/Third_Party/uCOS_III/uCOS_CONFIG/: cpu_cfg.h lib_cfg.h os_app_hooks.c os_cfg.h os_cfg_app.h
software components: CMSIS:CORE 4.3.0
